# Keil uVision project STEP_MOTOR.uvprojx, settings and files
target Step_motor (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.8.0
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: STEP_MOTOR +hex
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx
  c include: ..\CORE;..\USER;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\HALLIB\Inc;..\HARDWARE;..\SYSTEM\can
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: stm32f4xx_hal_msp.c stm32f4xx_it.c system_stm32f4xx.c main.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
    ./: can.c
  group CORE
    ../CORE/: cmsis_armcc.h core_cm4.h core_cmFunc.h core_cmInstr.h core_cmSimd.h startup_stm32f407xx.s
  group HALLIB
    ../HALLIB/Src/: stm32f4xx_hal.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_usart.c stm32f4xx_hal_cortex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_ll_usb.c stm32f4xx_hal_can.c
  group HARDWARE
    ../HARDWARE/: PWM.c MOTOR.c Emm_42.c ROS.c
    ./: SENSOR.c
